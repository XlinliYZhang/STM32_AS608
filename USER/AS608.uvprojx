# Keil uVision project AS608.uvprojx, settings and files
target AS608 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AS608 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\SDIO;..\HARDWARE\W25QXX;..\HARDWARE\24CXX;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\MALLOC;..\USMART;..\HARDWARE\AS608;..\HARDWARE\USART2;..\HARDWARE\BEEP;..\HARDWARE\LED;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c lcd_init.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_dma.c
  group README
    ../: README.TXT
